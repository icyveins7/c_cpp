options:
  parameters:
    author: seolubuntu
    generate_options: qt_gui
    id: FM_mod_backtest
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: audio_fs
  id: variable
  parameters:
    value: '24000'
  states: {}
- name: audio_play_vol
  id: variable_qtgui_range
  parameters:
    label: Audio Device Volume (dB)
    start: '-20'
    step: '0.1'
    stop: '20'
    value: '0'
  states: {}
- name: audio_playback_device
  id: variable_qtgui_entry
  parameters:
    label: Audio Playback Device
    type: string
    value: Paste the playback device
  states: {}
- name: audio_rec_device
  id: variable_qtgui_entry
  parameters:
    label: Audio Recording Device
    type: string
    value: Paste the recording device
  states: {}
- name: audio_rec_gain
  id: variable_qtgui_range
  parameters:
    label: Audio Device Recording Gain (dB)
    start: '-20'
    step: '0.1'
    stop: '20'
    value: '0'
  states: {}
- name: down
  id: variable
  parameters:
    value: '1'
  states: {}
- name: fc
  id: variable
  parameters:
    value: 90e6
  states: {}
- name: rxgain
  id: variable
  parameters:
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: audio_fs * up / down
  states: {}
- name: txgain
  id: variable
  parameters:
    value: '30'
  states: {}
- name: up
  id: variable
  parameters:
    value: '10'
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '15000'
    audio_stop: '16000'
    chan_rate: audio_fs
    deviation: '75000'
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: analog_fm_preemph_0
  id: analog_fm_preemph
  parameters:
    fh: '-1.0'
    samp_rate: audio_fs
    tau: '75e-6'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters: {}
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: audio_playback_device
    samp_rate: audio_fs
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: audio_rec_device
    samp_rate: audio_fs
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(audio_rec_gain/10)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(audio_play_vol/10)
    type: float
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: down
    interp: up
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: up
    interp: down
    type: ccc
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    gain0: txgain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: fc
    gain0: rxgain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [analog_fm_preemph_0, '0', analog_frequency_modulator_fc_0, '0']
- [analog_frequency_modulator_fc_0, '0', rational_resampler_xxx_0, '0']
- [audio_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', analog_fm_preemph_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_0, '0']
- [rational_resampler_xxx_0, '0', uhd_usrp_sink_0, '0']
- [rational_resampler_xxx_0_0, '0', analog_fm_demod_cf_0, '0']
- [uhd_usrp_source_0, '0', rational_resampler_xxx_0_0, '0']

metadata:
  file_format: 1
